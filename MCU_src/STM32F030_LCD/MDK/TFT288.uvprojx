# Keil uVision project TFT288.uvprojx, settings and files
target TFT288 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F030K6 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x1000) IROM(0x08000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: TFT288 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F030
  c include: ..\CORE;..\USER;..\HARDWARE\DELAY;..\HARDWARE\LCD;..\HARDWARE\TIM16;..\HARDWARE\ENCODER;..\HARDWARE\IIC;..\HARDWARE\STM8Slave;..\HARDWARE\ADC
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group USER
    ../USER/: main.c display.c control.c
  group HARDWARE
    ../HARDWARE/DELAY/: delay.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/TIM16/: TIM16.c
    ../HARDWARE/ENCODER/: ENCODER.c
    ../HARDWARE/IIC/: iic.c
    ../HARDWARE/STM8Slave/: STM8Slave.c
    ../HARDWARE/ADC/: ADC.c adc.s
  group CORE
    ../CORE/: startup_stm32f0xx.s stm32f0xx_it.c system_stm32f0xx.c
