# IAR project STM8S003_MAX2871_LCD13232.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: src
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: STM8S003_MAX2871_LCD13232.hex
  ILINK.IlinkOutputFile: STM8S903_LCD13232_TM7707_Meters.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    src/: delay.c delay.h EEPROM.c EEPROM.h IIC.c IIC.h main.c MAX2871.c MAX2871.h max2891_pll_conf.h RedPitaya.c RedPitaya.h stm8s.h Timer4.c Timer4.h
