<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\STM8S003_MAX2871_LCD13232.ewp</path>
  </project>
  <batchBuild/>
</workspace>


